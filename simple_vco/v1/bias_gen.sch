v {xschem version=3.4.5 file_version=1.2}

G {}

K {}

V {}

S {}

E {}

C {devices/iopin.sym} 0 -60 3 0 {name=p1 lab=VPWR sim_pinnumber=1}

C {devices/iopin.sym} 0 60 1 0 {name=p2 lab=VGND sim_pinnumber=2}

C {devices/ipin.sym} -60 -20 0 0 {name=p3 lab=en sim_pinnumber=3}

C {devices/ipin.sym} -60 20 0 0 {name=p4 lab=ctrl sim_pinnumber=4}

C {devices/opin.sym} 60 0 2 0 {name=p5 lab=bias_out sim_pinnumber=5}
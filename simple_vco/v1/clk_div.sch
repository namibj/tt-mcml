v {xschem version=3.4.5 file_version=1.2}

G {}

K {}

V {}

S {}

E {}

C {devices/iopin.sym} 0 -80 3 0 {name=p1 lab=VPWR sim_pinnumber=1}

C {devices/iopin.sym} 0 80 1 0 {name=p2 lab=VGND sim_pinnumber=2}

C {devices/ipin.sym} -80 -40 0 0 {name=p3 lab=ctrl sim_pinnumber=3}

C {devices/ipin.sym} -80 -20 0 0 {name=p4 lab=bias_in sim_pinnumber=4}

C {devices/ipin.sym} -80 20 0 0 {name=p5 lab=clk_p sim_pinnumber=5}

C {devices/ipin.sym} -80 40 0 0 {name=p6 lab=clk_n sim_pinnumber=6}

C {devices/opin.sym} 80 0 2 0 {name=p7 lab=clk_out sim_pinnumber=7}